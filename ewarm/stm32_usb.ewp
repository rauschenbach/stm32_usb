# IAR project stm32_usb.ewp, settings and files
configuration stm32_usb (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; STM32F40_41xxx; ARM_MATH_CM4; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..; ..\comport; ..\sys; ..\periph; ..\eeprom; ..\sensors; ..\proto; ..\usb; ..\utils; ..\Libraries\CMSIS\Include; ..\Libraries\STM32F407-Discovery; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\Libraries\STM32_USB_Device_Library\Class\msc_cdc_wrapper\inc; ..\Libraries\STM32_USB_Device_Library\Core\inc; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\Libraries\FreeRTOS\Source\include; ..\Libraries\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\; ..\Libraries\FreeRTOS\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: stm32_usb.sim
  ILINK.IlinkOutputFile: stm32_usb.out
  ILINK.IlinkIcfFile: stm32_usb.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group Libraries/FreeRTOS
    ../Libraries/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../Libraries/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../Libraries/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Libraries/STM32_USB_Device_Library/Class/CDC
    ../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group Libraries/STM32_USB_Device_Library/Class/MSC
    ../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group Libraries/STM32_USB_Device_Library/Class/MSC_CDC
    ../Libraries/STM32_USB_Device_Library/Class/msc_cdc_wrapper/src/: usbd_msc_cdc_wrapper.c
  group Libraries/STM32_USB_Device_Library/Core
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group Libraries/STM32_USB_OTG_Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group Libraries/stm32f4_discovery
    ../Libraries/STM32F407-Discovery/: stm32_sdio_sd.c stm32f4_discovery.c
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group periph
    ../periph/: led.c rtc.c spi.c systick.c timer.c
  group proto
    ../proto/: status.c
  group sys
    ../sys/: startup_stm32f40xx.s stm32f4xx_it.c system_stm32f4xx.c
  group usb
    ../usb/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c vcp.c
  group utils
    ../utils/: circbuf.c crc16.c utils.c
